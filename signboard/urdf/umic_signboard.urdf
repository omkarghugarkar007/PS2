Commit message: Update umic_signboard.urdf

File: signboard/urdf/umic_signboard.urdf (robot description, URDF)
Before this commit: robot umic_signboard, 1 links, 0 joints
Links:
- link umic_signboard: mass 0.12224 -> 2.12224
